Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: Project Number
Time: 2023-10-02T13:21:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.80.35 - Exporter 21.1.80.35 - Alternate UI 21.1.80.35
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 02 13:21:18 2023 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\c191ff9c-5f20-4208-bb73-df6f8efe2307\329ef586-a85f-48ec-8246-9d35697d816f\ifc * Database version: 5507 * Database creation date: Mon Oct 02 13:21:13 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 02 13:21:13 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 02 13:21:13 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Awaiting Approval

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding, n/a
LongName: n/a
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
In: n/a
LongName: Level 0; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels

# IfcDistributionPort (8)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
2 x Port_461457
2 x Port_461467
2 x Port_461477
2 x Port_461491

# IfcFlowTerminal: (2), 33
In: Level 0
Type - PredefinedType: WASTETRAP; Material: DBLTD_Duten_Metal_BrushedStainlessSteel
Type - Pset_DistributionFlowElementCommon - Reference: Brushed Stainless Steel Offset Bottle Trap & Extension Tube
Type - Pset_ElementShading - Color: Brushed Stainless Steel, Chrome, Matt Black, PVD Brass
Type - Pset_ManufacturerTypeInformation - ModelReference: Brushed Stainless Steel Offset Bottle Trap & Extension Tube; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Bottle Trap; Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Brushed Stainless Steel Offset Bottle Trap & Extension Tube
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowTerminal: (3), 34
In: Level 0
Type - PredefinedType: WASTETRAP; Material: DBLTD_Duten_Metal_Chrome
Type - Pset_DistributionFlowElementCommon - Reference: Chrome Offset Bottle Trap & Extension Tube
Type - Pset_ElementShading - Color: Brushed Stainless Steel, Chrome, Matt Black, PVD Brass
Type - Pset_ManufacturerTypeInformation - ModelReference: Chrome Offset Bottle Trap & Extension Tube; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Bottle Trap; Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Chrome Offset Bottle Trap & Extension Tube
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowTerminal: (4), 35
In: Level 0
Type - PredefinedType: WASTETRAP; Material: DBLTD_Duten_Metal_MatteBlack
Type - Pset_DistributionFlowElementCommon - Reference: Matt Black Offset Bottle Trap & Extension Tube
Type - Pset_ElementShading - Color: Brushed Stainless Steel, Chrome, Matt Black, PVD Brass
Type - Pset_ManufacturerTypeInformation - ModelReference: Matt Black Bottle Trap & Extension Tube; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Bottle Trap; Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Matt Black Offset Bottle Trap & Extension Tube
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowTerminal: DBLTD_Duten_SanitaryApplianceTraps_A810:Brass Bottle Trap & Extension Tube, 32
In: Level 0
Type - PredefinedType: WASTETRAP; Material: DBLTD_Duten_Metal_BrushedBrass
Type - Pset_DistributionFlowElementCommon - Reference: Brass Bottle Trap & Extension Tube
Type - Pset_ElementShading - Color: Brushed Stainless Steel, Chrome, Matt Black, PVD Brass
Type - Pset_ManufacturerTypeInformation - ModelReference: Brass Bottle Trap & Extension Tube; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Bottle Trap; Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Brass Bottle Trap & Extension Tube
Pset_DistributionFlowElementCommon - sets with these values: 2
